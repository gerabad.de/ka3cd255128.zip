Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_47/temp/tmp_2780_169_DcQaX/format_2/1420(architecture=300).ifc
Time: 2025-08-11T06:29:43
Made in: PARTsolutions

# IfcProject, 1420(architecture=300)
Description: PURO NEXT

# IfcDiscreteAccessory, 1420(architecture=300)
In: BUILDING
Description: 1420(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1420
ePset_PARTsolutions - NB: 1420(architecture=300); NN: 1420; NT: PURO NEXT; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1420(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1420; B: 1420.png; C: PURO NEXT; E: KALDEWEI; EF000049: 1600; EF004567: 700
